# Keil uVision project obd_wifi.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K142HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x1FFFC000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: obd_wifi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\nxpLib;.\include;.\wifi\common\include;.\wifi;.\wifi\bus_wrapper\include;.\wifi\bsp\include;.\wifi\socket\include;.\wifi\driver\include;..\obd_wifi;.\wifi\driver\source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: .\RTE\Device\S32K142HAxxxLHx\S32K142_32_flash.sct
  group src
    ./: main.c
  group nxpLib
    ./nxpLib/: canbus.c clocks_and_modes.c flash_driver.c gpio.c nxpQueue.c pcc_hal.c spi.c timer.c uart.c printf.c
  group wifi
    ./wifi/bsp/source/: nm_bsp.c
    ./wifi/common/source/: nm_common.c
    ./wifi/bus_wrapper/source/: nm_bus_wrapper.c
    ./wifi/driver/source/: m2m_ate_mode.c m2m_crypto.c m2m_hif.c m2m_ota.c m2m_periph.c m2m_ssl.c m2m_wifi.c nmasic.c nmbus.c nmdrv.c nmi2c.c nmspi.c nmuart.c
    ./wifi/socket/source/: socket.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.0.0
